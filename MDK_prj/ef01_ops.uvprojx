# Keil uVision project ef01_ops.uvprojx, settings and files
target ef01_ops (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ef01_ops +hex
  AfterMake: fromelf.exe --bin -o ./ef01_ops.bin  ./Objects/ef01_ops.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Source\User;..\Source\OS;..\Source\ST_Libraries
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ST_Libraries\Startup
    ../Source/ST_Libraries/Startup/: startup_stm32f10x_md.s
  group ST_Libraries\CMSIS
    ../Source/ST_Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group ST_Libraries\STM32F4xx_StdPeriph_Driver
    ../Source/ST_Libraries/STM32F10x_StdPeriph_Driver/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group OS
    ../Source/OS/: OS.c OS.h OS_Conf.h OS_CLASS.h
  group User
    ../Source/User/: main.c pwm.c
    ../Source/ST_Libraries/: stm32f10x_it.c
  group User\serial_debug
    ../Source/User/serial_debug/: serial_debug.c
  group User\Led
    ../Source/User/Led/: Led.c Task_Led.c
  group User\Communication
    ../Source/User/Communication/: FIFO.C tp_msg.c uart_tp.c Task_Communication.c uart.c
  group User\Sprayer
    ../Source/User/Sprayer/: Nozzle.c Pump.c Sprayer.c Valve.c Task_Sprayer.c
  group User\Heartbeat
    ../Source/User/Heartbeat/: Task_Heartbeat.c
  group User\LiquidCapacity
    ../Source/User/LiquidCapacity/: CapacityData.c CapacityNotifyHandle.c FDC1004.c LiquidCapacity.c Task_LiquidCapacity.c
